Vin 1 0 10
L1 1 2 0.001
C1 2 3 1E-6
R1 3 0 1000
